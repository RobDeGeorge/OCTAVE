#include "font.h"

#include <ctype.h>
#include <string.h>

/* Each glyph: 5 rows of 5 cells, '#' lit. Lowercase is drawn as uppercase. */
typedef struct { char ch; const char *rows[5]; } Glyph;

static const Glyph glyphs[] = {
    {'A', {" ### ", "#   #", "#####", "#   #", "#   #"}},
    {'B', {"#### ", "#   #", "#### ", "#   #", "#### "}},
    {'C', {" ####", "#    ", "#    ", "#    ", " ####"}},
    {'D', {"#### ", "#   #", "#   #", "#   #", "#### "}},
    {'E', {"#####", "#    ", "#### ", "#    ", "#####"}},
    {'F', {"#####", "#    ", "#### ", "#    ", "#    "}},
    {'G', {" ####", "#    ", "#  ##", "#   #", " ####"}},
    {'H', {"#   #", "#   #", "#####", "#   #", "#   #"}},
    {'I', {"#####", "  #  ", "  #  ", "  #  ", "#####"}},
    {'J', {"    #", "    #", "    #", "#   #", " ### "}},
    {'K', {"#   #", "#  # ", "###  ", "#  # ", "#   #"}},
    {'L', {"#    ", "#    ", "#    ", "#    ", "#####"}},
    {'M', {"#   #", "## ##", "# # #", "#   #", "#   #"}},
    {'N', {"#   #", "##  #", "# # #", "#  ##", "#   #"}},
    {'O', {" ### ", "#   #", "#   #", "#   #", " ### "}},
    {'P', {"#### ", "#   #", "#### ", "#    ", "#    "}},
    {'Q', {" ### ", "#   #", "# # #", "#  # ", " ## #"}},
    {'R', {"#### ", "#   #", "#### ", "#  # ", "#   #"}},
    {'S', {" ####", "#    ", " ### ", "    #", "#### "}},
    {'T', {"#####", "  #  ", "  #  ", "  #  ", "  #  "}},
    {'U', {"#   #", "#   #", "#   #", "#   #", " ### "}},
    {'V', {"#   #", "#   #", "#   #", " # # ", "  #  "}},
    {'W', {"#   #", "#   #", "# # #", "## ##", "#   #"}},
    {'X', {"#   #", " # # ", "  #  ", " # # ", "#   #"}},
    {'Y', {"#   #", " # # ", "  #  ", "  #  ", "  #  "}},
    {'Z', {"#####", "   # ", "  #  ", " #   ", "#####"}},
    {'0', {" ### ", "#  ##", "# # #", "##  #", " ### "}},
    {'1', {"  #  ", " ##  ", "  #  ", "  #  ", " ### "}},
    {'2', {" ### ", "#   #", "  ## ", " #   ", "#####"}},
    {'3', {"#### ", "    #", " ### ", "    #", "#### "}},
    {'4', {"#  # ", "#  # ", "#####", "   # ", "   # "}},
    {'5', {"#####", "#    ", "#### ", "    #", "#### "}},
    {'6', {" ### ", "#    ", "#### ", "#   #", " ### "}},
    {'7', {"#####", "    #", "   # ", "  #  ", "  #  "}},
    {'8', {" ### ", "#   #", " ### ", "#   #", " ### "}},
    {'9', {" ### ", "#   #", " ####", "    #", " ### "}},
    {' ', {"     ", "     ", "     ", "     ", "     "}},
    {'.', {"     ", "     ", "     ", "     ", "  #  "}},
    {',', {"     ", "     ", "     ", "  #  ", " #   "}},
    {':', {"     ", "  #  ", "     ", "  #  ", "     "}},
    {'-', {"     ", "     ", "#####", "     ", "     "}},
    {'+', {"     ", "  #  ", "#####", "  #  ", "     "}},
    {'/', {"    #", "   # ", "  #  ", " #   ", "#    "}},
    {'%', {"##  #", "## # ", "  #  ", " # ##", "#  ##"}},
    {'!', {"  #  ", "  #  ", "  #  ", "     ", "  #  "}},
    {'?', {" ### ", "#   #", "  ## ", "     ", "  #  "}},
    {'\'', {"  #  ", "  #  ", "     ", "     ", "     "}},
    {'(', {"  #  ", " #   ", " #   ", " #   ", "  #  "}},
    {')', {"  #  ", "   # ", "   # ", "   # ", "  #  "}},
    {'<', {"   # ", "  #  ", " #   ", "  #  ", "   # "}},
    {'>', {" #   ", "  #  ", "   # ", "  #  ", " #   "}},
    {'=', {"     ", "#####", "     ", "#####", "     "}},
    {'*', {"# # #", " ### ", "#####", " ### ", "# # #"}},
    {'&', {" ##  ", "#  # ", " ##  ", "#  # ", " ## #"}},
    {'#', {" # # ", "#####", " # # ", "#####", " # # "}},
    {'_', {"     ", "     ", "     ", "     ", "#####"}},
    {'"', {" # # ", " # # ", "     ", "     ", "     "}},
    /* a few glyphs the pages draw as symbols */
    {'\x01', {"  #  ", " ### ", "#####", "  #  ", "  #  "}},   /* up arrow */
    {'\x02', {"  #  ", "  #  ", "#####", " ### ", "  #  "}},   /* down arrow */
    {'\x03', {"#    ", "###  ", "#####", "###  ", "#    "}},   /* play */
    {'\x04', {"## ##", "## ##", "## ##", "## ##", "## ##"}},   /* pause */
    {'\x05', {"#   #", "#  ##", "# # #", "#  ##", "#   #"}},   /* next (|>) */
    {'\x06', {"#   #", "##  #", "# # #", "##  #", "#   #"}},   /* prev */
    {'\x07', {"  #  ", " ### ", "#####", " ### ", "  #  "}},   /* diamond */
};

static const Glyph *find(char c)
{
    c = (char)toupper((unsigned char)c);
    for (size_t i = 0; i < sizeof glyphs / sizeof glyphs[0]; i++)
        if (glyphs[i].ch == c)
            return &glyphs[i];
    return find('?');
}

int font_width(const char *text, int scale)
{
    int n = (int)strlen(text);
    return n ? n * 6 * scale - scale : 0;
}

void font_draw(SDL_Renderer *r, int x, int y, int scale, const char *text)
{
    for (const char *p = text; *p; p++) {
        const Glyph *g = find(*p);
        for (int row = 0; row < 5; row++)
            for (int col = 0; col < 5; col++)
                if (g->rows[row][col] == '#') {
                    SDL_Rect px = {x + col * scale, y + row * scale, scale, scale};
                    SDL_RenderFillRect(r, &px);
                }
        x += 6 * scale;
    }
}

void font_draw_centered(SDL_Renderer *r, int x, int w, int y, int scale, const char *text)
{
    font_draw(r, x + (w - font_width(text, scale)) / 2, y, scale, text);
}

void font_draw_right(SDL_Renderer *r, int x_right, int y, int scale, const char *text)
{
    font_draw(r, x_right - font_width(text, scale), y, scale, text);
}
